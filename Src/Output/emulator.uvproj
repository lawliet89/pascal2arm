# Keil uVision project emulator.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: emulator
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x1000
  memory RVCT2: ROM 0x1000 size 0x1000
  memory RVCT6: RAM 0x2000 size 0x3000
  group Source Group 1
    ./: test.s
